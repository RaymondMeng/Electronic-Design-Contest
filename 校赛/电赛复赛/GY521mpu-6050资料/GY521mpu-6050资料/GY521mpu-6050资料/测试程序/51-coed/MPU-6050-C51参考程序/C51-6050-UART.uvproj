# Keil uVision project C51-6050-UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: C51-6050-UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: C51-6050-UART.C
